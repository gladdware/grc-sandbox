<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wbfm_rx</value></param>
<param><key>title</key><value>Broadcast FM RX</value></param>
<param><key>author</key><value>agaldd</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0</value></param>
<param><key>label</key><value>RX</value></param>
<param><key>value</key><value>lo_freq+offset_coarse+offset_fine</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>lo_freq</value></param>
<param><key>label</key><value>LO</value></param>
<param><key>value</key><value>88e6</value></param>
<param><key>min</key><value>52e6</value></param>
<param><key>max</key><value>2240e6</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tune_freq</value></param>
<param><key>value</key><value>lo_freq+offset_coarse+offset_fine</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>guis</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['RF', 'Baseband', 'Audio']</value></param>
<param><key>grid_pos</key><value>0,0,1,2</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate/fft_decim</value></param>
<param><key>baseband_freq</key><value>lo_freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>800,300</value></param>
<param><key>notebook</key><value>guis,0</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset_coarse</value></param>
<param><key>label</key><value>Coarse Tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-(samp_rate/2)/2</value></param>
<param><key>max</key><value>(samp_rate/2)/2</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,0,1,2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset_fine</value></param>
<param><key>label</key><value>Fine Tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-5e3</value></param>
<param><key>max</key><value>5e3</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>3,0,1,2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, 90e3, 5e3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_decim</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_decim</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>rtlsdr_source_c</key>
<param><key>id</key><value>rtlsdr_source_c_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>lo_freq</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>gain_mode0</key><value>1</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>if_gain0</key><value>24</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate/xlate_decim</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.75</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>guis,1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>fft_decim</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>samp_rate/2/fft_decim</value></param>
<param><key>width</key><value>10e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>gr_freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>gr_freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>xlate_decim</value></param>
<param><key>taps</key><value>xlate_taps</value></param>
<param><key>center_freq</key><value>-(offset_coarse+offset_fine)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>48e3</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.75</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>guis,2</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>af_gain</value></param>
<param><key>label</key><value>AF Gain</value></param>
<param><key>value</key><value>3</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>10</value></param>
<param><key>num_steps</key><value>10</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>af_cutoff_hz</value></param>
<param><key>label</key><value>AF Filter</value></param>
<param><key>value</key><value>15e3</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>48e3/2</value></param>
<param><key>num_steps</key><value>480</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>4,1,1,1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>af_gain</value></param>
<param><key>samp_rate</key><value>48e3</value></param>
<param><key>cutoff_freq</key><value>af_cutoff_hz</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blks2_wfm_rcv</key>
<param><key>id</key><value>blks2_wfm_rcv_0</value></param>
<param><key>quad_rate</key><value>samp_rate/xlate_decim</value></param>
<param><key>audio_decimation</key><value>1</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>int((samp_rate/xlate_decim)/1e3)</value></param>
<param><key>interp</key><value>48</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>blks2_fm_deemph</key>
<param><key>id</key><value>blks2_fm_deemph_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate/xlate_decim</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<connection><source_block_id>rtlsdr_source_c_0</source_block_id><sink_block_id>gr_freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blks2_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_c_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_fftsink2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>wxgui_fftsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_wfm_rcv_0</source_block_id><sink_block_id>blks2_fm_deemph_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_fm_deemph_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_wfm_rcv_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
